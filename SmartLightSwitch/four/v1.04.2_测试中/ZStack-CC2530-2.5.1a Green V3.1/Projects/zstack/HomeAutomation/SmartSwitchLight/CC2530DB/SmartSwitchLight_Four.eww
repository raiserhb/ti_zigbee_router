<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SmartSwitchLight_Four.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SmartSwitchLight_Four</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SmartSwitchLight_Four</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SmartSwitchLight_Four</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


